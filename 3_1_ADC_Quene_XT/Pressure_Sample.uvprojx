# Keil uVision project Pressure_Sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1302-T038x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.10.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLDC_double closed loop +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Peripherals_Drive;.\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Main
    ./Main/: main.c
  group Peripherals_Drive
    ./Peripherals_Drive/: SCU.c GPIO.c CCU4.c VADC.c USIC.c
  group System
    ./SYSTEM/: Var_Init.c User_Func.c Irq_Handle.c
software components: CMSIS:CORE 5.1.2, Device:RTE_Device 1.1.0, Device:Startup 2.4.0, Device:XMClib:GPIO 2.1.22, Device:XMClib:SCU 2.1.22, Device:XMClib:UART 2.1.22
